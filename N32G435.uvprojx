# Keil uVision project N32G435.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G435KB Nationstech
  pack: Nationstech.N32G43x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x6000) IRAM2(0x20006000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G435 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USER;.\USER\src;.\firmware\CMSIS\device;.\firmware\n32g43x_std_periph_driver\inc;.\inc
  memory RVCT4: ROM 0x8002000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x20006000 size 0x2000
  group User
    ./USER/: main.c Init.c AdcProcedure.c AdcProcedure.h LoadCoilControlProcedure.c LoadCoilControlProcedure.h InclineControlProcedure.c
  group MCU
    ./firmware/CMSIS/device/: system_n32g43x.c
    ./firmware/CMSIS/device/startup/: startup_n32g43x.s
  group Driver
    ./firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_adc.c n32g43x_dbg.c n32g43x_dma.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_iwdg.c n32g43x_lpuart.c n32g43x_rcc.c n32g43x_tim.c n32g43x_usart.c n32g43x_wwdg.c
  group inc
    ./inc/: CommunicationProcedure.h OperationModeProcedure.h
  group scr
    ./src/: CommunicationProcedure.c n32g43x_cfg(USART).c n32g43x_it(USART).c OperationModeProcedure.c
software components: CMSIS:CORE 5.5.0
